# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\NET\device;..\NET\MQTT;..\NET\onenet;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\DHT11;..\HARDWARE\ADC;..\HARDWARE\DS18B20;..\HARDWARE\KEY;..\HARDWARE\GY_906;..\HARDWARE\upPC;..\HARDWARE\send_uart;..\HARDWARE\usart3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_dma.c
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/GY_906/: GY_906.c GY_I2C.c
    ../HARDWARE/adc/: bsp_adc.c
    ../HARDWARE/upPC/: ToUpperComputer.c
    ../HARDWARE/send_uart/: send_uart.c
    ../HARDWARE/usart3/: bsp_usart.c
